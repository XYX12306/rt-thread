# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: R7FA6E2BB Renesas
  pack: Renesas.RA_DFP.5.6.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: rtthread +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
