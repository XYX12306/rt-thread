# Keil uVision project project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: R7FA6E2BB Renesas
  pack: Renesas.RA_DFP.5.6.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: rtthread +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: packages\FlexibleButton-latest;..\..\..\libcpu\arm\common;..\libraries\HAL_Drivers\config;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\smp;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\io\eventfd;board\ports;..\..\..\components\drivers\include;..\libraries\HAL_Drivers;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;packages\mpu6xxx-latest\inc;board;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\include;packages\peripheral_samples-latest;packages\ssd1306-latest\inc;.;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;packages\dht11-latest
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c dev_soft_i2c.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_alarm.c dev_rtc.c
    ../../../components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group dht11
    packages/dht11-latest/: dht11_sample.c sensor_dallas_dht11.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_rtc.c drv_usart_v2.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c msh.c shell.c
  group flex_button
    packages/FlexibleButton-latest/: flexible_button.c
    packages/FlexibleButton-latest/examples/: demo_rtt_iotboard.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group mpu6xxx
    packages/mpu6xxx-latest/src/: mpu6xxx.c sensor_inven_mpu6xxx.c
    packages/mpu6xxx-latest/samples/: mpu6xxx_sample.c
  group peripheral-samples
    packages/peripheral_samples-latest/: iwdg_sample.c rtc_sample.c
  group ssd1306
    packages/ssd1306-latest/src/: ssd1306.c ssd1306_fonts.c
    packages/ssd1306-latest/examples/: ssd1306_tests.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
